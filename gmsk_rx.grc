<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>value</key><value>28</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1280500000</value></param>
</block>
<block>
<key>blks2_gmsk_demod</key>
<param><key>id</key><value>blks2_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>rx_video_fifo</value></param>
<param><key>file</key><value>rxfifo.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>350000</value></param>
<param><key>width</key><value>50000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>gmsk_rx</value></param>
<param><key>title</key><value>Video Receiver (GMSK)</value></param>
<param><key>author</key><value>Alexandru Csete OZ9AEC</value></param>
<param><key>description</key><value>Requires UHD</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_single_usrp_source</key>
<param><key>id</key><value>uhd_single_usrp_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>ref_clk</key><value></value></param>
<param><key>sd_spec</key><value>B:</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>1.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>blks2_gmsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>rx_video_fifo</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>blks2_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_single_usrp_source</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_single_usrp_source</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
